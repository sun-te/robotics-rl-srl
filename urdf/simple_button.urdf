Commit message: experiments params

File: urdf/simple_button.urdf (robot description, URDF)
Before this commit: robot simple_push_button, 3 links, 2 joints
Links:
- link simple_push_button__cylinder: mass 5 -> 5000
